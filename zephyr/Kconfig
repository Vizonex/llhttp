## zephyr/Kconfig
```kconfig
config LLHTTP
	bool "llhttp HTTP parser library"
	help
	  Enable the llhttp HTTP request/response parser.
```
